# Keil uVision project SepticTankV1.0.uvprojx, settings and files
target SepticTankV1.0 (5060183::V5.06 update 2 (build 183)::.\ARMCC)
  device: HC32F448KCTI HDSC
  pack: HDSC.HC32F448.1.1.0
  cpu: IROM1(0x0,0x40000) IROM2(0x3000C00,0x400) IRAM1(0x1FFF8000,0x10000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: SepticTankV1.0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __DEBUG,HC32F448,USE_DDL_DRIVER,
  c include: ..\APP;..\BSP;..\BSP\ch4;..\BSP\flash;..\BSP\water;..\COMMON;..\DRIVER\inc;..\BSP\EC01;..\BSP\H2S;..\BSP\GPS;..\BSP\EC01\OneNet
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x3000c00 size 0x400
  memory RVCT9: RAM 0x1fff8000 size 0x10000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: ..\COMMON\config\linker\HC32F448xC.sct
  link misc: --keep=*Handler
  group APP
    ../APP/: handle.c main.c dataproce.c
  group BSP
    ../BSP/: CRC_SUM.c hardware.c power.c ADC.c
  group BSP/CH4
    ../BSP/ch4/: YL_WI_YY_6001.c
  group BSP/FLASH
    ../BSP/flash/: flash.c
  group BSP/WATER
    ../BSP/water/: HLK-LD2413.c
  group BSP/H2S
    ../BSP/H2S/: PS_H2S_100.c
  group BSP/EC01
    ../BSP/EC01/: EC_01.c
  group BSP/EC01/OneNet
    ../BSP/EC01/OneNet/: base64.c hmac.c md5.c token.c
  group BSP/GPS
    ../BSP/GPS/: GP_02.c
  group BSP/TTL
    ../BSP/: TTL.c
  group COMMON
    ../COMMON/: system_hc32f448.c startup_hc32f448.s
  group DRIVER
    ../DRIVER/src/: hc32_ll.c hc32_ll_adc.c hc32_ll_aos.c hc32_ll_clk.c hc32_ll_cmp.c hc32_ll_efm.c hc32_ll_fcg.c hc32_ll_gpio.c hc32_ll_i2c.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_pwc.c hc32_ll_rtc.c hc32_ll_sram.c hc32_ll_tmr0.c hc32_ll_usart.c hc32_ll_utility.c hc32_ll_rmu.c
software components: Data Exchange:JSON:cJSON 1.7.7

# Keil uVision project hufenchi.uvprojx, settings and files
target hufenchi (5060183::V5.06 update 2 (build 183)::.\ARMCC)
  device: STM32L071RBTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.3.1.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: hufenchi +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32L071xx
  c include: ..\APP;..\BSP;..\BSP\MIDDLEWARE;..\BSP\CH4;..\BSP\H2S;..\BSP\RADAR;..\BSP\ACCSPEED;..\BSP\BATTER;..\BSP\TEMPHUM;..\BSP\4G;..\BSP\FLASH;..\BSP\LOWPOWER;..\DRIVER\STM32L0xx_HAL_Driver\Inc;..\DRIVER\CMSIS\Include;..\DRIVER\CMSIS\Device\ST\STM32L0xx\Include;..\FreeRTOS\Source\include;..\FreeRTOS\Source\CMSIS_RTOS_V2;..\FreeRTOS\Source\portable\RVDS\ARM_CM0
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ../APP/: main.c stm32l0xx_it.c stm32l0xx_hal_conf.h FreeRTOSConfig.h
  group APP/TASK
    ../APP/Task/: netTask.c slowTask.c uartTask.c
  group BSP
    ../BSP/: system_stm32l0xx.c stm32l0xx_hal_msp.c dataProcess.c
  group BSP/MIDDLEWARE
    ../BSP/MIDDLEWARE/: gpio.c i2c.c sysclk.c tim.c usart.c rtc.c
  group BSP/CH4
    ../BSP/CH4/: ch4.c
  group BSP/H2S
    ../BSP/H2S/: h2s.c
  group BSP/RADAR
    ../BSP/RADAR/: radar.c
  group BSP/4G
    ../BSP/4G/: EC800M.c
  group BSP/ACCSPEED
    ../BSP/ACCSPEED/: IIS2DLP.c
  group BSP/BATTER
    ../BSP/BATTER/: bq35100.c
  group BSP/TEMPHUM
    ../BSP/TEMPHUM/: HDC2010.c
  group BSP/FLASH
    ../BSP/FLASH/: eeprom.c
  group BSP/LOWPOWER
    ../BSP/LOWPOWER/: lowpower.c
  group DRIVER
    ../DRIVER/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_exti.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c
    ../DRIVER/: startup_stm32l071xx.s
  group DRIVER/CMSIS
    ../DRIVER/CMSIS/Device/ST/STM32L0xx/Include/: stm32l0xx.h stm32l071xx.h system_stm32l0xx.h
  group FreeRTOS
    ../FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
software components: CMSIS:CORE 6.1.0
